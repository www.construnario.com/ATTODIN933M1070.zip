Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\IFC\ATLAS\NIVEL 01\ATTODIN933M1070.ifc
Time: 2017-02-22T21:09:21
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: ATORNILLO CIERRE ATLAS 01 M10, TORNILLO
In: Planta Baja
Description: TORNILLO ATLAS 01; Material: Color_01
PROPIEDADES GENERALES - COMPOSICIÓN: NYLON; COLOR: TRANSLÚCIDO
Pset_ManufacturerTypeInformation - ArticleNumber: TORNILLO CIERRE SISTEMA ATLAS 01 M10; ModelReference: ATTODIN933M1070; ModelLabel: ATTODIN933M1070; Manufacturer: JOMBAR; ProductionYear: 2017
